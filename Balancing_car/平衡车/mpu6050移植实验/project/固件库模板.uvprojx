# Keil uVision project 固件库模板.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 固件库模板 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\User;..\librires\CMSIS;..\librires\STM32F10x_StdPeriph_Driver\inc;..\User\USART;..\User\I2C;..\User\MPU6050;..\User\MPU6050\eMPL;..\User\sys;..\User\delay
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../librires/CMSIS/startup/: startup_stm32f10x_md.s
  group USER
    ../User/: stm32f10x_it.c main.c
    ../User/USART/: USART.c
    ../User/MPU6050/: mpuiic.c mpu6050.c
    ../User/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../User/sys/: sys.c
    ../User/delay/: delay.c
  group CMSIS
    ../librires/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../librires/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DOC
    ../Doc/: readme.txt
