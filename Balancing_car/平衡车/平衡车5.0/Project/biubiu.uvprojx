# Keil uVision project biubiu.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: diandenglala +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\GOIO_Config;..\User\MPU6050\iic;..\User\PWM;..\User\usart;..\User\MPU6050\KALMAN;..\User\MPU6050\mpu6050;..\User\MPU6050\SysTick;..\User\motor;..\User\hc_sr04;..\User\bmq;..\User\MPU6050\DMP;..\User\MPU6050;..\User\sys;..\User\OLED;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: stm32f10x_it.c main.c
    ../User/usart/: usart.c
    ../User/GOIO_Config/: GPIO_config.c
    ../User/MPU6050/iic/: iic.c
    ../User/MPU6050/SysTick/: systick_delay.c
    ../User/PWM/: pwm.c
    ../User/motor/: motor.c
    ../User/hc_sr04/: hc_sr04.c
    ../User/bmq/: bmq.c
    ../User/MPU6050/: MPU6050.c TIME.c
    ../User/MPU6050/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../User/sys/: sys.c
    ../User/OLED/: oled.c
  group LOC
    ../Doc/: readme.txt
